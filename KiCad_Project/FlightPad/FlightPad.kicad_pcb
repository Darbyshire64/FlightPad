# Repository Darbyshire64/FlightPad

File README.md:

# MultiPad
An Multifunctional inspired macro pad. That im submiting for @HackClub's <a href="highway.hackclub.com">highway</a>. The macro pad has a minimalist but functional design, With Multi layerd functionality

# Features

  - 9 Keys aranged in 3x3 Patern
  - Cherry MX Linear Switches
  - Multi Profile (3 Profiles)
  - OLED Displaying information and profile in use.

# Layout

|    OLED |        | ESP 32 |
|---------|--------|--------|
|    1    |    2   |    3   |
|    4    |    5   |    6   |
|    7    |    8   |    9   |

# The Function Key

The Blue Function key is designed to allow changing of settings of the macro pad.

##  Setings

Hold down F(BLUE) key for 3 Seconds to enter customization mode. use 5 and 8 to scroll. Key 2 to modify option. Hold F Key again to exit and apply. 

Available Setings Below:

|Setting        | Options    | Desc        |
|---------------|------------|-------------|
|Toggle OLED    | On  Off    | Toggles OLED.   |
|Toggle NP      | On  Off    | Toggles NP      |
|Default Profile| 1 2 3      | Sets the Inital Profile|

## Live Switch Profile 

Hold F Key and Key 7 for 3 seconds. OLED and Neo Pixle Will light regardless of settings. and use keys 4-6 to select profile and use Key 7 to exit.

# Photos
## Case

# PCB

## KiCad design KiCad_Project/FlightPad/FlightPad.kicad_pcb

Board: 2 copper layers, 70.5 x 94.0 mm, 20 parts (9 on the bottom side), 7 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9: D; DO35-10
J1: Conn_01x04_Pin; SSD1306-0.91-OLED-4pin-128x32
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+3V3: J1.2, U1.12 (3V3)
COL-1: SW2.1, SW5.1, SW8.1, U1.1 (GPIO26/ADC0/A0)
COL-2: SW3.1, SW6.1, SW9.1, U1.2 (GPIO27/ADC1/A1)
COL-3: SW4.1, SW7.1, SW10.1, U1.3 (GPIO28/ADC2/A2)
GND: J1.1, U1.13 (GND)
SCL: J1.3, U1.6 (GPIO7/SCL)
SDA: J1.4, U1.5 (GPIO6/SDA)

## Commit log

2025-07-07 Created the Intial Kicad repo
2025-07-07 Added the RP2040 and Created the Key matrix
2025-07-07 Addded Rp2040 and added the key matrix
    That last commit was funky did realise i was merging files
2025-07-07 Added the Oled display. Tidied up the schematic. added a description
2025-07-07 Finished off the PCB.
    still got some work to do tho. so will do that later
2025-07-08 Did the case
2025-07-08 Added More Pics
2025-07-12 Added 3D Models
2025-07-12 Created Prod Files
